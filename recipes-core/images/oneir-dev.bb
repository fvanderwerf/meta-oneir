require oneir.bb

DESCRIPTION = "oneir including dev packages"

IMAGE_FEATURES += "dev-pkgs"

